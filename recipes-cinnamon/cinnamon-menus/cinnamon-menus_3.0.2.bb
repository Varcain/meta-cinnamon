SUMMARY = "Cinnamon Menus"
SECTION = "x11/libs"
LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=b234ee4d69f5fce4486a80fdaf4a4263"
DEPENDS = ""

inherit cinnamon autotools gettext gobject-introspection

SRC_URI[md5sum] = "02410dc1a16ca6f0d4940fecb0535833"
SRC_URI[sha256sum] = "e17494e65edb6ca8b36e05ca21316db8ce6864d4f9bfa9312a661d5c39054ad7"
