SUMMARY = "Cinnamon Control Center"
SECTION = "x11/libs"
LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=75859989545e37968a99b631ef42722e"
DEPENDS = ""

inherit cinnamon autotools gettext gobject-introspection

SRC_URI[md5sum] = "2474b9f929758bffb121a33a139bc03a"
SRC_URI[sha256sum] = "3d9f0eb45168a91101f99452b38184dd6417dd89064be4523e565bd721a521fe"
